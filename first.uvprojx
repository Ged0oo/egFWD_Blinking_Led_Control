# Keil uVision project first.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PGE Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: first +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=4
  c include: .\egFWD_Blinking_Led_Control\Src\Common;.\egFWD_Blinking_Led_Control\Src\Config;.\egFWD_Blinking_Led_Control\Src\Mcal\Inc;.\egFWD_Blinking_Led_Control\Src\Hal
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Config
    ./egFWD_Blinking_Led_Control/Src/Config/: Dio_Lcfg.c Gpt_Lcfg.c IntCtrl_Lcfg.c Systick_Lcfg.c
  group App
    ./egFWD_Blinking_Led_Control/Src/Appl/: main.c
  group Hal
    ./egFWD_Blinking_Led_Control/Src/Hal/: Led.c
  group Mcal
    ./egFWD_Blinking_Led_Control/Src/Mcal/: Dio.c Gpt.c IntCtrl.c Systic.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
